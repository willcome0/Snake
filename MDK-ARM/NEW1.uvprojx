# Keil uVision project NEW1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SKEAZ128xxx4 NXP
  pack: Keil.Kinetis_KEAxx_DFP.1.3.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: NEW1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\Inc;..\Drivers;..\Drivers\CMSIS;..\Snake
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group USER
    ../Scr/: main.c key.c oled.c
  group SNAKE
    ../Snake/: snake.c
  group DEVICE
    ../Drivers/: gpio.c uart.c delay.c pit.c upper.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
